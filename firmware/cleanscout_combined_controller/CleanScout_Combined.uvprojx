# Keil uVision project CleanScout_Combined.uvprojx, settings and files
target CleanScout_Combined (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CleanScout_Combined +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Drivers\inc;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group SPL
    ./Drivers/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./User/: main.c stm32f10x_it.c csr_board_map.c csr_motor_drv.c csr_encoder_drv.c board_resource_map.c csr_motion_link.c csr_motion_controller.c arm_protocol.c arm_host_link.c arm_servo_bus.c arm_servo_executor.c safety_supervisor.c
